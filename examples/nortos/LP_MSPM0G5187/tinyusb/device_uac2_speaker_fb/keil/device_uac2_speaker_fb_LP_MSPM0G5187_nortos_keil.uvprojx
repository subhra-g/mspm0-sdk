# Keil uVision project device_uac2_speaker_fb_LP_MSPM0G5187_nortos_keil.uvprojx, settings and files
target device_uac2_speaker_fb_LP_MSPM0G5187_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G5187 Texas Instruments
  output: device_uac2_speaker_fb_LP_MSPM0G5187_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' device_uac2_speaker_fb.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G5187__,__USE_SYSCONFIG__,__MSPM0G518X__,CFG_TUSB_MCU=OPT_MCU_MSPM0G518X
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source/,../../../../../../source/ti,../../../../../../source/ti/devices/msp,../../../../../../source/ti/driverlib,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source/third_party/tinyusb/src,../../../../../../source/third_party/tinyusb/hw,../../../../../../source/third_party/tinyusb/hw/bsp/mspm0,../../../../../../source/third_party/tinyusb/hw/mcu/ti/mspm0/,../../../../../../source
  scatter file: ./mspm0g5187.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g518x/driverlib.a
  group Source
    ../third_party/tinyusb/src/portable/mentor/musb/: dcd_musb.c hcd_musb.c dcd_musbfsfc.h musb_ti.h musb_type.h
    ../: main.c tusb_config.h usb_descriptors.c usb_descriptors.h common_types.h quirk_os_guessing.c quirk_os_guessing.h device_uac2_speaker_fb.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ../third_party/tinyusb/hw/bsp/: ansi_escape.h board.c board_api.h board_mcu.h
    ../third_party/tinyusb/hw/bsp/mspm0/boards/lp-mspm0c5116/: board.h
    ../third_party/tinyusb/hw/bsp/mspm0/boards/lp-mspm0g5117/: board.h
    ../third_party/tinyusb/hw/bsp/mspm0/boards/lp-mspm0g5187/: board.h
    ../third_party/tinyusb/hw/bsp/mspm0/: family.c family.h
    ../third_party/tinyusb/src/class/audio/: audio.h audio_device.c audio_device.h
    ../third_party/tinyusb/src/class/bth/: bth_device.c bth_device.h
    ../third_party/tinyusb/src/class/cdc/: cdc.h cdc_device.c cdc_device.h cdc_host.c cdc_host.h cdc_rndis.h cdc_rndis_host.c cdc_rndis_host.h
    ../third_party/tinyusb/src/class/cdc/serial/: ch34x.h cp210x.h ftdi_sio.h
    ../third_party/tinyusb/src/class/dfu/: dfu.h dfu_device.c dfu_device.h dfu_rt_device.c dfu_rt_device.h
    ../third_party/tinyusb/src/class/hid/: hid.h hid_device.c hid_device.h hid_host.c hid_host.h
    ../third_party/tinyusb/src/class/midi/: midi.h midi_device.c midi_device.h
    ../third_party/tinyusb/src/class/msc/: msc.h msc_device.c msc_device.h msc_host.c msc_host.h
    ../third_party/tinyusb/src/class/net/: ecm_rndis_device.c ncm.h ncm_device.c net_device.h
    ../third_party/tinyusb/src/class/usbtmc/: usbtmc.h usbtmc_device.c usbtmc_device.h
    ../third_party/tinyusb/src/class/vendor/: vendor_device.c vendor_device.h vendor_host.c vendor_host.h
    ../third_party/tinyusb/src/class/video/: video.h video_device.c video_device.h
    ../third_party/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
    ../third_party/tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
    ../third_party/tinyusb/src/host/: hcd.h hub.c hub.h usbh.c usbh.h usbh_pvt.h
    ../third_party/tinyusb/src/osal/: osal.h osal_freertos.h osal_mynewt.h osal_none.h osal_pico.h osal_rtthread.h osal_rtx4.h
    ../third_party/tinyusb/src/: tusb.c tusb.h tusb_option.h
    ./: startup_mspm0g518x_uvision.s
