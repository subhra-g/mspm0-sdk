# Keil uVision project fatfs_sd_spi_LP_MSPM0L2228_nortos_keil.uvprojx, settings and files
target fatfs_sd_spi_LP_MSPM0L2228_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0L2228 Texas Instruments
  output: fatfs_sd_spi_LP_MSPM0L2228_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../../../../../tools/keil/syscfg.bat '$P' fatfs_sd_spi.syscfg"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0L2228__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0l2228.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0l122x_l222x/driverlib.a
  group Source
    ../: fatfs_sd_spi.c sd_spi.c fatfs_sd_spi.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ../FatFS/: diskio.h ff_time.c ff.c ff.h ffconf.h ffsystem.c ffunicode.c
    ./: startup_mspm0l222x_uvision.s
